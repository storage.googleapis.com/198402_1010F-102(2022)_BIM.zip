Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-19T22:28:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 19 22:28:13 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{FB65E0BC-39D4-473E-B586-14A0AA74695D}\ifc * Database version: 5507 * Database creation date: Wed Jan 19 22:28:10 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 19 22:28:11 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 19 22:28:11 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1010F-102 Washbasin faucet, 1010F-102(2022):1010F-102 Washbasin faucet:422898
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 144 mm; NominalHeight: 147 mm; NominalWidth: 50 mm
Type - General - Author: BIMStone; BIMObjectName: 1010F-102(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with fixed spout and aerator; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/01/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1490; EAN Number: 6414150099908; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Sales Package dimensions (LxWxH): 540 x 146 x 59; Sales Package gross weight: 1.352 kg; Sales Package package weight: 0.1912 kg; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/1010F-102; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/1010F-102/original; URL REACH: http://static.oras.com/doc/reach
Type - Identity Data - Catalog Drawing URL: http://static.oras.com/catdrw/1010F-102; Dimension Drawing URL: http://static.oras.com/dimdrw/1010F-102; FDV Document URL: http://www.oras.com/datasheet/1010F-102/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1010F-102; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1010F-102; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1010F-102; Model: 1010F-102 Washbasin faucet; Name_en: 1010F-102 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1010F-102; Product data url: https://www.bimobject.com/oras/product/1010f; Product Family: Oras Safira Eco; Product Image URL: http://static.oras.com/image/1010F-102; Product URL: http://static.oras.com/1010F-102; Spare-Part Information URL: http://static.oras.com/sp/1010F-102; Technical DataSheet URL: http://www.oras.com/datasheet/1010F-102/en; Type Name: 1010F-102 Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Chain holder without chain; Flow Rate At 300kPa With Flow Controller: 0.00988811 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Noise Class: I (ISO 3822) Oras lab.; Spout Projection: 107 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1010F-102(2022); Features: Single-lever;Green Building; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1010F-102; Name: 1010F-102 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x144x147 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1010F-102; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1010F-102 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0368175 m2; Volume: 0.00106311 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1010F-102(2022): 1010F-102 Washbasin faucet; Family and Type: 1010F-102(2022): 1010F-102 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1010F-102(2022): 1010F-102 Washbasin faucet; Type Id: 1010F-102(2022): 1010F-102 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
